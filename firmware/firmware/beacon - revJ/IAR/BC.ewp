# IAR project BC.ewp, settings and files
configuration Debug-Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BEACON_APP; USE_STDPERIPH_DRIVER; STM32F10X_CL; COOS; USE_MY_ASSERT; _DEBUG; BOOTLOADER; EE_M24C02; TASKS_PROFILE; BATTERY_CHECK; CCA_EN_NO; NEW_BEACON; USE_TIM4; WDT_ENABLE; OLD_CONFIG; CIRCULAR_LOG; BC_HW_REVJ
  ICCARM.CCIncludePath2: ..\App; ..\..\common\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common\STM32F10x_StdPeriph_Driver\inc; ..\..\common\CoOS\kernel; ..\..\common\CoOS\portable; ..\..\..\common; ..\..\common\USB-Device-CDC; ..\..\common; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: REVJ-BC-Debug-Loadable.bin
  ILINK.IlinkOutputFile: BC.out
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release-Bootloader (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: BEACON_APP; USE_STDPERIPH_DRIVER; STM32F10X_CL; COOS; BC_HW_REVJ; _NDEBUG; EE_M24C02; TASKS_PROFILE; BATTERY_CHECK; NEW_BEACON; USE_TIM4; WDT_ENABLE; OLD_CONFIG; CIRCULAR_LOG; BOOTLOADER
  ICCARM.CCIncludePath2: ..\App; ..\..\common\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common\USB-Device-CDC; ..\..\common\STM32F10x_StdPeriph_Driver\inc; ..\..\common\CoOS\kernel; ..\..\common\CoOS\portable; ..\..\..\common; ..\..\common; $PROJ_DIR$
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: RevJ-BC-Release-Loadable.bin
  group CMSIS
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CoOS
    ../../common/CoOS/portable/: arch.c portForM3.asm
    ../../common/CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mutex.c queue.c sem.c serviceReq.c task.c time.c
  group STM32F10x_StdPeriph_Driver
    ../../common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group USB_Device_CDC
    ../../common/USB-Device-CDC/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_USER
    ../../common/USB-Device-CDC/: usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group User
    ../../../common/: base64.c base64.h console_tail.cpp
    ../App/: basic_rf.c bitmaps.c blkt_gfx.c config.c eink.c eink_comms.c font16pt12.c font9pt7.c hardware.c i2c_ee.c i2c_periph.c i2c_periph.h ina219_defs.h main.c radio.c stm32f10x_it.c tasks.c
    ../../common/: util.c
    ./: VersionNo.h

# IAR project TK630.ewp, settings and files
configuration Release-Bootloader (ARM)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; COOS; USE_MY_ASSERT; TIMEKEEPER; TIMEKEEPER_APP; xEther_active; TK_V3_hdwr; BOOTLOADER; EE_M24C02; TASKS_PROFILE; xSEND_PACKETS; MULTI_CHANNEL; xUSE_RANDOM; TK_SYNCED_CLOCK
  ICCARM.CCIncludePath2: ..\App; ..\..\common\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common\USB-Device-CDC; ..\..\common\STM32F10x_StdPeriph_Driver\inc; ..\..\common\STM32_ETH_Driver\inc; ..\..\common\CoOS\kernel; ..\..\common\CoOS\portable; ..\Ethernet\app; ..\Ethernet\TK_ethernet; ..\..\common\uip; ..\..\common\uip\httpd; ..\Test_dbg; ..\..\..\Common; ..\..\Common; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TK-Release-Loadable.bin
  ILINK.IlinkOutputFile: TK-Release-Loadable.out
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-Bootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; COOS; USE_MY_ASSERT; TIMEKEEPER; TIMEKEEPER_APP; xEther_active; TK_V3_hdwr; _DEBUG; BOOTLOADER; EE_M24C02; TASKS_PROFILE; xSEND_PACKETS; MULTI_CHANNEL; xUSE_RANDOM; xNUCLEAR
  ICCARM.CCIncludePath2: ..\App; ..\..\common\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common\STM32F10x_StdPeriph_Driver\inc; ..\..\common\STM32_ETH_Driver\inc; ..\..\common\USB-Device-CDC; ..\..\common\CoOS\kernel; ..\..\common\CoOS\portable; ..\Ethernet\app; ..\Ethernet\TK_ethernet; ..\..\common\uip; ..\..\common\uip\httpd; ..\Test_dbg; ..\..\..\Common; ..\..\Common; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: TK-Debug-Loadable.bin
  prebuild: cmd /c "set PROJ_DIR=$PROJ_DIR$ && build_num.bat"
  ILINK.IlinkOutputFile: TK.out
  group CMSIS
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CoOS
    ../../common/CoOS/portable/: arch.c portForM3.asm
    ../../common/CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mutex.c queue.c sem.c serviceReq.c task.c time.c
  group STM32_ETH_DRIVER
    ../../common/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32F10x_StdPeriph_Driver
    ../../common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group uIP
    ../Ethernet/app/: clock-arch.c ethernet.c
    ../../common/uip/: dhcpc.c uip.c uip_arp.c Uip_Timer.c uiplib.c
    ../Ethernet/TK_ethernet/: ether_1.c TCP_process.c udp_process.c
  group USB-Device-CDC
    ../../common/USB-Device-CDC/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group User
    ../../../common/: base64.c console_tail.cpp
    ../App/: basic_rf.c config.c FlashUpdate.c hardware.c main.c radio.c stm32f10x_it.c
    ../../common/: i2c_ee.c util.c
    ../Test_dbg/: Tst_Dbg.c

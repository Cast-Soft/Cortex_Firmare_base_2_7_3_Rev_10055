<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Router-72.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Router</name>
      <member>
        <project>Router-72</project>
        <configuration>Debug-Bootloader</configuration>
      </member>
      <member>
        <project>Router-72</project>
        <configuration>Release-Bootloader</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



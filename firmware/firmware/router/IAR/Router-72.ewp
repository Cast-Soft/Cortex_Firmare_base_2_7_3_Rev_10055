# IAR project Router-72.ewp, settings and files
configuration Debug-Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xB ST STM32F107xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; COOS; USE_MY_ASSERT; ROUTER_APP; ROUTER; TK_V3_hdwr; _DEBUG; BOOTLOADER; EE_M24C02; TASKS_PROFILE; DEBUG_OUTPUT; WDT_ENABLE
  ICCARM.CCIncludePath2: ..\App; ..\..\common\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common\STM32F10x_StdPeriph_Driver\inc; ..\..\common\STM32_ETH_Driver\inc; ..\..\common\CoOS\kernel; ..\..\common\CoOS\portable; ..\Ethernet\app; ..\Ethernet\TK_ethernet; ..\..\common\uip; ..\..\common\uip\httpd; ..\Test_dbg; ..\..\..\common; ..\..\common\USB-Device-CDC; ..\..\common; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RT-Debug-Loadable.bin
  prebuild: cmd /c "set PROJ_DIR=$PROJ_DIR$ && build_num.bat"
  ILINK.IlinkOutputFile: Router.out
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release-Bootloader (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; COOS; ROUTER_APP; ROUTER; Ether_active; TK_V3_hdwr; _NDEBUG; BOOTLOADER; EE_M24C02; TASKS_PROFILE; WDT_ENABLE
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: RT-Release-Loadable.bin
  group CMSIS
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CoOS
    ../../common/CoOS/portable/: arch.c portForM3.asm
    ../../common/CoOS/kernel/: core.c event.c flag.c hook.c kernelHeap.c mbox.c mutex.c queue.c sem.c serviceReq.c task.c time.c
  group STM32_ETH_DRIVER
    ../../common/STM32_ETH_Driver/src/: stm32_eth.c
  group STM32F10x_StdPeriph_Driver
    ../../common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group uIP
    ../Ethernet/app/: clock-arch.c ethernet.c
    ../../common/uip/: dhcpc.c uip.c uip_arp.c Uip_Timer.c uiplib.c
    ../Ethernet/TK_ethernet/: ether_1.c TCP_process.c udp_process.c
  group USB_Device_CDC
    ../../common/USB-Device-CDC/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group User
    ../../../common/: base64.c
    ../App/: basic_rf.c config.c hardware.c i2c_ee.c main.c radio.c stm32f10x_it.c
    ../Test_dbg/: Tst_Dbg.c

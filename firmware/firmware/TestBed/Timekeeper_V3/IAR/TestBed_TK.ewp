# IAR project TestBed_TK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TK_TestBed; USE_MY_ASSERT; Ether_active; USE_STDPERIPH_DRIVER; STDIO_TO_USART_NO; COOS; STM32F10X_CL; TK_V3_hdwr
  ICCARM.CCIncludePath2: ..\App; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\STM32_USB-FS-Device_Driver\inc; ..\STM32F10x_StdPeriph_Driver\inc; ..\STM32_ETH_Driver\inc; C:\Program Files\IAR Systems\Embedded Workbench 6.30\arm\CMSIS\Include; ..\CoOS\kernel; ..\CoOS\portable; ..\Ethernet\app; ..\Ethernet\TK_ethernet; ..\Ethernet\uip; ..\Ethernet\uip\httpd; ..\Test_dbg; ..\..\..\..\Common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TestBed_TK.srec
  ILINK.IlinkOutputFile: TestBed_TK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMISS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group CoOS
    ../CoOS/portable/: arch.c portForM3.asm
    ../CoOS/kernel/: core.c event.c flag.c hook.c mbox.c mutex.c serviceReq.c task.c time.c
  group Ethernet
    ../Ethernet/app/: clock-arch.c ethernet.c
    ../Ethernet/TK_ethernet/: ether_1.c TCP_process.c udp_process.c
  group STM32_ETH_Driver
    ../STM32_ETH_Driver/src/: stm32_eth.c
  group STM32_USB-FS-Device_Driver
    ../STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uIP
    ../Ethernet/uip/: dhcpc.c psock.c uip.c uip_arp.c Uip_Timer.c uiplib.c
  group USER
    ../App/: basic_rf.c beacon.c FlashUpdate.c hardware.c i2c_ee.c main.c radio.c stm32f10x_it.c usb_desc.c usb_endp.c usb_hw_config.c usb_istr.c usb_prop.c usb_pwr.c
    ../Test_dbg/: Tst_Dbg.c

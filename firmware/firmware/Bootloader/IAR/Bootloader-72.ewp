# IAR project Bootloader-72.ewp, settings and files
configuration Debug-Beacon (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xB ST STM32F107xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; BEACON; DEBUG
  ICCARM.CCIncludePath2: ..\..\common\uip\; ..\..\common\uip\httpd; ..\Ethernet\app\; ..\App\; ..\..\common\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\common\USB-Device-CDC; ..\..\common\STM32F10x_StdPeriph_Driver\inc; ..\..\common\STM32_ETH_Driver\inc; ..\..\..\common; ..\..\common; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader4Beacon-Debug.bin
  prebuild: cmd /c "set PROJ_DIR=$PROJ_DIR$ && build_num.bat"
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release-Beacon (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; BEACON
  OBJCOPY.OOCOutputFile: Bootloader4Beacon-Release.bin
configuration Debug-TK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; USE_ETHERNET; TIMEKEEPER
  OBJCOPY.OOCOutputFile: Bootloader4TK-Debug.bin
  ILINK.IlinkIcfFile: stm32f107xB.icf
configuration Release-TK (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: Bootloader4TK-Release.bin
configuration Debug-Router (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; USE_ETHERNET; ROUTER
  OBJCOPY.OOCOutputFile: Bootloader4Router-Debug.bin
configuration Release-Router (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: Bootloader4Router-Release.bin
configuration Debug-MainMemory-Beacon (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; BEACON; MAIN_MEMORY
  OBJCOPY.OOCOutputFile: BC-BootloaderUpgrade-Debug.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
configuration Release-MainMemory-Beacon (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: BC-BootloaderUpgrade-Release.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
configuration Debug-MainMemory-TK (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; USE_ETHERNET; TIMEKEEPER; MAIN_MEMORY
  OBJCOPY.OOCOutputFile: TK-BootloaderUpgrade-Debug.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
configuration Release-MainMemory-TK (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: TK-BootloaderUpgrade-Release.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
configuration Debug-MainMemory-Router (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_CL; USE_MY_ASSERT; USE_ETHERNET; ROUTER; MAIN_MEMORY
  OBJCOPY.OOCOutputFile: RT-BootloaderUpgrade-Debug.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
configuration Release-MainMemory-Router (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: RT-BootloaderUpgrade-Release.bin
  ILINK.IlinkIcfFile: stm32f10x_flash_boot.icf
  group App
    ../App/: app_util.c hardware.c main.c md5.c stm32f10x_it.c
    ../../../common/: base64.c
  group CMSIS
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    ../../common/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Ethernet
    ../Ethernet/app/: clock-arch.c ether.c ethernet.c udp_process.c
    ../../common/STM32_ETH_Driver/src/: stm32_eth.c
    ../Ethernet/uip/: uip.c uip_arp.c Uip_Timer.c
  group STM32F10x_StdPeriph_Driver
    ../../common/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group USB_Device_Driver
    ../../common/STM32F10x_StdPeriph_Driver/src/: stm32f10x_dbgmcu.c
    ../../common/USB-Device-CDC/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_cdc_core.c usbd_cdc_vcp.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c

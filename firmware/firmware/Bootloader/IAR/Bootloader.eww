<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Bootloader.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Bootloader</project>
        <configuration>Debug-Beacon</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Debug-Router</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Debug-TK</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Release-Beacon</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Release-Router</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Release-TK</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Debug-MainMemory-Beacon</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Debug-MainMemory-Router</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Debug-MainMemory-TK</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Release-MainMemory-Beacon</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Release-MainMemory-Router</configuration>
      </member>
      <member>
        <project>Bootloader</project>
        <configuration>Release-MainMemory-TK</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



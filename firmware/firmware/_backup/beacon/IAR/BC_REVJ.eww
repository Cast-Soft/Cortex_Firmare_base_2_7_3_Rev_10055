<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\beacon - Copy\IAR\BC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


